# Keil uVision project project.uvprojx, settings and files
target project (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;..\Hero_Code\Alogrithm\PID;..\Hero_Code\Chassis;..\Hero_Code\Task;..\Hero_Code\Device\BMI088;..\Hero_Code\Device\DR16;..\Hero_Code\Device\Motor_DJI;..\Hero_Code\Device\VOFA;..\Hero_Code\Driver\CAN;..\Hero_Code\Driver\MATH;..\Hero_Code\Driver\SPI;..\Hero_Code\Driver\TIM;..\Hero_Code\Driver\USART;..\Hero_Code\Board_Communication_Slave;..\Hero_Code\Device\Motor_DM;..\Hero_Code\Booster_DM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Hero_Code/Alogrithm/PID/: alg_pid.c alg_pid.h
    ../Hero_Code/Chassis/: chassis.c chassis.h
    ../Hero_Code/Device/BMI088/: BMI088Middleware.c BMI088Middleware.h BMI088reg.h dvc_bmi088.c dvc_bmi088.h
    ../Hero_Code/Device/DR16/: dvc_dr16.c dvc_dr16.h
    ../Hero_Code/Device/Motor_DJI/: dvc_motor_DJI.c dvc_motor_DJI.h
    ../Hero_Code/Device/VOFA/: dvc_vofa.c dvc_vofa.h
    ../Hero_Code/Driver/CAN/: drv_can.c drv_can.h
    ../Hero_Code/Driver/MATH/: drv_math.c drv_math.h
    ../Hero_Code/Driver/SPI/: drv_spi.c drv_spi.h
    ../Hero_Code/Driver/TIM/: drv_tim.c drv_tim.h
    ../Hero_Code/Driver/USART/: drv_usart.c drv_usart.h
    ../Hero_Code/Task/: task.c task.h
    ../Hero_Code/Board_Communication_Slave/: slave.c slave.h
    ../Hero_Code/Device/Motor_DM/: dvc_motor_DM.C dvc_motor_DM.h
    ../Hero_Code/Booster_DM/: booster_dm.c booster_dm.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 6.1.0
